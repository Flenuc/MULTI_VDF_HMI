#include "ScaleTable.h"

namespace ScaleTable {

// Per-index scale for P0 / P1 (0..47). 0 means "use 1".
// Manual unit: 0.1→10, 0.01→100, 0.001→1000, 1→1
static const uint16_t kP0Scale[48] = {
  /*00*/ 10,  /*01*/ 10,  /*02*/ 1,   /*03*/ 10,  /*04*/ 1,
  /*05*/ 1000,/*06*/ 10,  /*07*/ 100, /*08*/ 1,   /*09*/ 10,
  /*10*/ 10,  /*11*/ 100, /*12*/ 10,  /*13*/ 10,  /*14*/ 1,
  /*15*/ 10,  /*16*/ 1,   /*17*/ 100, /*18*/ 1,   /*19*/ 1,
  /*20*/ 10,  /*21*/ 10,  /*22*/ 10,  /*23*/ 10,  /*24*/ 10,
  /*25*/ 1,   /*26*/ 10,  /*27*/ 100, /*28*/ 10,  /*29*/ 10,
  /*30*/ 1,   /*31*/ 1,   /*32*/ 10,  /*33*/ 10,  /*34*/ 100,
  /*35*/ 100, /*36*/ 10,  /*37*/ 10,  /*38*/ 1,   /*39*/ 1,
  /*40*/ 1,   /*41*/ 1,   /*42*/ 1000,/*43*/ 1,   /*44*/ 1,
  /*45*/ 1,   /*46*/ 1,   /*47*/ 1,
};

// Field: P1-05/06/14 = 0.01 Hz (6000→60.00). Carrier P1-09 0.1 kHz → 10
static const uint16_t kP1Scale[48] = {
  /*00*/ 1,   /*01*/ 1,   /*02*/ 1,   /*03*/ 1,   /*04*/ 1,
  /*05*/ 100, /*06*/ 100, /*07*/ 100, /*08*/ 1,   /*09*/ 10,
  /*10*/ 100, /*11*/ 10,  /*12*/ 1,   /*13*/ 10,  /*14*/ 100,
  /*15*/ 1,   /*16*/ 1,   /*17*/ 1,   /*18*/ 1,   /*19*/ 1,
  /*20*/ 1,   /*21*/ 1,   /*22*/ 1,   /*23*/ 1,   /*24*/ 1,
  /*25*/ 1,   /*26*/ 1,   /*27*/ 1,   /*28*/ 1,   /*29*/ 100,
  /*30*/ 1,   /*31*/ 100, /*32*/ 10,  /*33*/ 1,   /*34*/ 1,
  /*35*/ 1,   /*36*/ 1,   /*37*/ 1,   /*38*/ 1,   /*39*/ 1,
  /*40*/ 1,   /*41*/ 1,   /*42*/ 1,   /*43*/ 1,   /*44*/ 1,
  /*45*/ 1,   /*46*/ 1,   /*47*/ 1,
};

static const char *const kP0Unit[48] = {
  "bar", "bar", "", "bar", "", "", "s", "s", "", "s",
  "s", "Hz", "s", "bar", "", "s", "", "Hz", "s", "s",
  "", "bar", "s", "bar", "s", "", "bar", "Hz", "%", "s",
  "min", "", "bar", "s", "V", "V", "s", "s", "", "",
  "", "C", "", "", "", "", "", "",
};

static const char *const kP1Unit[48] = {
  "", "", "", "", "min", "Hz", "Hz", "Hz", "", "kHz",
  "V", "s", "", "kW", "Hz", "", "", "", "", "",
  "", "", "", "", "", "", "", "", "", "Hz",
  "", "Hz", "s", "", "", "", "", "", "ms", "",
  "", "", "", "", "", "", "", "",
};

uint16_t scaleOf(uint8_t group, uint8_t index) {
  if (index > 47) return 1;
  uint16_t s = (group == 0) ? kP0Scale[index] : (group == 1) ? kP1Scale[index] : 1;
  return s == 0 ? 1 : s;
}

const char *unitOf(uint8_t group, uint8_t index) {
  if (index > 47) return "";
  if (group == 0) return kP0Unit[index];
  if (group == 1) return kP1Unit[index];
  return "";
}

}  // namespace ScaleTable
